# Keil uVision project AM32_Bootloader_STC8051U.uvproj, settings and files
target Bootloader (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: AM32_Bootloader_STC8051U +hex
  group Inc
    ./Inc/: nstdbool.h nstdint.h version.h
    ./Mcu/8051U/Inc/: blutil.h eeprom.h main.h
  group Src
    ./bootloader/: main.c
    ./Mcu/8051U/Src/: eeprom.c

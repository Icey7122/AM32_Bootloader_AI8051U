# Keil uVision project AM32_Bootloader_STC32.uvproj, settings and files
target Bootloader (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: AM32_Bootloader_STC32 +hex
  group inc
    ./Bootloader/inc/: nstdint.h nstdbool.h main.h bootloader.h
  group src
    ./Bootloader/src/: bootloader.c main.c
